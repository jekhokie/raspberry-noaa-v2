options:
  parameters:
    author: otti
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
    run_options: run
    title: Meteor QPSK LRPT
  states: {}

blocks:
- name: bitstream_name
  id: variable
  parameters:
    value: '"/Users/d2/Desktop/meteor_LRPT_" + datetime.now().strftime("%d%m%Y_%H%M") + ".s"'
  states: {}
- name: clock_alpha
  id: variable
  parameters:
    value: '0.002'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '8'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '137100000'
  states: {}
- name: pll_alpha
  id: variable
  parameters:
    value: '0.006'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: samp_rate_airspy/decim
  states: {}
- name: samp_rate_airspy
  id: variable
  parameters:
    value: '1250000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: (samp_rate*1.0)/(symb_rate*1.0)
  states: {}
- name: symb_rate
  id: variable
  parameters:
    value: '72000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '4000'
    rate: '1000e-4'
    reference: '0.5'
    type: complex
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '-1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: bitstream_name
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '127'
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: clock_alpha
    gain_omega: clock_alpha**2/4.0
    mu: '0.5'
    omega: sps
    omega_relative_limit: '0.005'
    type: complex
  states: {}
- name: digital_constellation_soft_decoder_cf_1
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: digital.constellation_calcdist(([-1-1j, -1+1j, 1+1j, 1-1j]), ([0, 1, 3, 2]), 4, 1).base()
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: pll_alpha
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_airspy
    fc: freq
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-100'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decim
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.6'
    decim: '1'
    gain: '1'
    ntaps: '361'
    samp_rate: samp_rate
    sym_rate: symb_rate
    type: fir_filter_ccf
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '0'
    bw0: '1500000'
    corr0: '68'
    freq0: freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate_airspy
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', root_raised_cosine_filter_0, '0']
- [analog_rail_ff_0, '0', blocks_float_to_char_0, '0']
- [blocks_float_to_char_0, '0', blocks_file_sink_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_constellation_soft_decoder_cf_1, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_constellation_soft_decoder_cf_1, '0', analog_rail_ff_0, '0']
- [digital_costas_loop_cc_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [rational_resampler_xxx_0, '0', analog_agc_xx_0, '0']
- [root_raised_cosine_filter_0, '0', digital_costas_loop_cc_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
