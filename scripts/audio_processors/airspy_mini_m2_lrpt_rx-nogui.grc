options:
  parameters:
    author: Mihajlo
    category: Custom
    generate_options: no_gui
    id: airspy_mini_m2_lrpt_rx
    output_language: python
    run_options: run
    title: Airspy Mini Meteor QPSK LRPT
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: '25'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '137100000'
  states: {}
- name: samp_rate_airspy
  id: variable
  parameters:
    value: 3e6
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: baseband.wav
    nchan: '2'
    samp_rate: int(samp_rate_airspy/decim)
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"airspy=0,pack=1"'
    bb_gain0: '20'
    bw0: '1500000'
    corr0: '68'
    freq0: freq
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '10'
    sample_rate: samp_rate_airspy
    sync: sync
    type: fc32
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decim
    interp: '1'
    type: ccc
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0, '1']
- [osmosdr_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
