options:
  parameters:
    author: Mihajlo
    category: Custom
    description: APT to WAV recorder for Raspberry-Noaa -V2
    generate_options: no_gui
    id: hackrf_noaa_apt_rx
    output_language: python
    run_options: run
    title: HackRF NOAA APT Receiver V1.0.0
  states: {}

blocks:
- name: cutoff
  id: variable
  parameters:
    value: '75000'
  states: {}
- name: fcd_freq
  id: variable
  parameters:
    value: '137500000'
  states: {}
- name: recfile
  id: variable
  parameters:
    value: '"/srv/audio/noaa/capture.wav"'
  states: {}
- name: samp_rate_hackrf
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: trans
  id: variable
  parameters:
    value: '25000'
  states: {}
- name: blks2_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: '100000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.7'
    type: float
  states: {}
- name: gr_wavfile_sink_0_0_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: recfile
    samp_rate: '11025'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: '40'
    gain: '1'
    samp_rate: samp_rate_hackrf
    type: fir_filter_ccf
    width: trans
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0,linearity,bias=0"'
    bb_gain0: '16'
    freq0: fcd_freq
    gain0: '14'
    gain_mode0: 'False'
    if_gain0: '18'
    sample_rate: samp_rate_hackrf
    sync: sync
    type: fc32
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4000'
    interp: '441'
    taps: ''
    type: fff
  states: {}

connections:
- [blks2_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', gr_wavfile_sink_0_0_0_0, '0']
- [low_pass_filter_0, '0', blks2_wfm_rcv_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
