options:
  parameters:
    author: otti & Mihajlo
    category: Custom
    generate_options: no_gui
    id: rtlsdr_m2_lrpt_rx
    output_language: python
    run_options: run
    title: Meteor QPSK LRPT
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: '10'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '137100000'
  states: {}
- name: samp_rate_rtlsdr
  id: variable
  parameters:
    value: '1250000'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: baseband.wav
    nchan: '2'
    samp_rate: int(samp_rate_rtlsdr/decim)
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decim
    fbw: '0.4'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: rtl=0,bias=0
    bb_gain0: '0'
    bw0: '1500000'
    freq0: freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate_rtlsdr
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0, '1']
- [rational_resampler_xxx_0, '0', blocks_complex_to_float_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
