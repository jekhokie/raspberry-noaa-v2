options:
  parameters:
    author: Mihajlo
    category: Custom
    generate_options: no_gui
    id: hackrf_m2_lrpt_rx
    output_language: python
    run_options: run
    title: Hackrf Meteor QPSK LRPT
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: '32'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '137100000'
  states: {}
- name: samp_rate_hackrf
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: baseband.wav
    nchan: '2'
    samp_rate: int(samp_rate_hackrf/decim)
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0,linearity,bias=0"'
    bb_gain0: '0'
    bw0: '1500000'
    freq0: freq
    gain0: '15'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate_hackrf
    sync: sync
    type: fc32
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decim
    fbw: '0.4'
    interp: '1'
    taps: ''
    type: ccc
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0, '1']
- [osmosdr_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
