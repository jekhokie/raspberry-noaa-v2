options:
  parameters:
    author: Mihajlo
    generate_options: no_gui
    id: FM_baseband_demodulator
    output_language: python
    run_options: run
    title: FM Baseband Demodulator
  states: {}

blocks:
- name: input_baseband
  id: variable
  parameters:
    value: '"/home/pi/input.wav"'
  states: {}
- name: output_baseband
  id: variable
  parameters:
    value: '"/home/pi/output.wav"'
  states: {}
- name: blks2_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: '110250'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.7'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: input_baseband
    nchan: '2'
    repeat: 'False'
  states: {}
- name: gr_wavfile_sink_0_0_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: output_baseband
    samp_rate: '11025'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '50000'
    decim: '1'
    gain: '1'
    samp_rate: '110250'
    type: fir_filter_ccf
    width: '25000'
    win: firdes.WIN_HAMMING
  states: {}

connections:
- [blks2_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', gr_wavfile_sink_0_0_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [low_pass_filter_0, '0', blks2_wfm_rcv_0, '0']

metadata:
  file_format: 1
